// sim_arduino.cpp — Trien khai shim cho PC.
#include "sim_arduino.h"
#include <sys/stat.h>
#include <vector>

SimSerial Serial;
SimWiFi WiFi;
LGFX *LGFX::inst = nullptr;
SimFS SD_MMC{ "sim_sd" };
SimFS LittleFS{ "sim_lfs" };
SimNet SIM_NETS[] = {
  { "Zzz-No-Service", -95, true },
  { "VNPT-Home",      -52, false },
  { "Viettel-4G",     -67, false },
  { "FPT-Wifi",       -73, false },
};
int SIM_NET_COUNT = 4;
char SIM_CONNECTED[64] = "";
char SIM_EXPECT_PASS[64] = "abc";
bool SIM_HTTP_MOCK = true;
int SIM_KEYS[10] = { 0,0,0,0,0,0,0,0,0,0 };   // 1 = pressed (LOW)

bool sim_http_mock() { return SIM_HTTP_MOCK; }
void sim_http_mock_set(bool on) { SIM_HTTP_MOCK = on; }

int sim_digitalRead(int pin) {
  static const int map_pin[] = { 18, 7, 15, 45, 17, 6, 8, 46, 5, 16 };
  for (int i = 0; i < 10; i++) if (map_pin[i] == pin) return SIM_KEYS[i] ? 0 : 1;
  return 1;
}

// ---------------- WiFiClient ----------------
static std::string g_req;
bool WiFiClient::connect(const char *host, int port, int) {
  rx.clear(); rxp = 0; g_req.clear(); ok = false;
  if (SIM_HTTP_MOCK) {
    ok = true;    // phan ung sinh o lan doc dau
    return true;
  }
  s = ::socket(AF_INET, SOCK_STREAM, 0);
  if (s == INVALID_SOCKET) return false;
  struct addrinfo hints = {}, *res = nullptr;
  hints.ai_family = AF_INET;
  char ps[8]; sprintf(ps, "%d", port);
  if (getaddrinfo(host, ps, &hints, &res) != 0 || !res) { closesocket(s); s = INVALID_SOCKET; return false; }
  if (::connect(s, res->ai_addr, (int)res->ai_addrlen) < 0) { freeaddrinfo(res); closesocket(s); s = INVALID_SOCKET; return false; }
  freeaddrinfo(res);
  ok = true;
  return true;
}
void WiFiClient::print(const char *s) {
  if (!s || !s[0]) return;
  if (SIM_HTTP_MOCK) { g_req += s; return; }
  if (ok && this->s != INVALID_SOCKET) ::send(this->s, s, (int)strlen(s), 0);
}
int WiFiClient::available() {
  if (SIM_HTTP_MOCK) {
    if (rx.empty() && !g_req.empty()) {
      // sinh phan ung WML mock cho moi host
      const char *body =
        "<wml><card title=\"Mock Server\"><p>Chao mung den Mock Server!<br/>"
        "<a href=\"mtt:start\">Ve trang chu</a><br/>"
        "<a href=\"/page2.wml\">Trang 2</a></p></card></wml>";
      char hdr[256];
      int hn = sprintf(hdr, "HTTP/1.1 200 OK\r\nContent-Type: text/vnd.wap.wml\r\nContent-Length: %d\r\n\r\n", (int)strlen(body));
      rx.assign(hdr, hn); rx += body;
    }
    return (int)rx.size() - (int)rxp;
  }
  // host TCP bridge (Winsock that)
  if (rxp < rx.size()) return (int)rx.size() - (int)rxp;
  if (!ok || s == INVALID_SOCKET) return 0;
  fd_set fds; FD_ZERO(&fds); FD_SET(s, &fds);
  timeval tv = { 0, 200000 };
  if (select((int)s + 1, &fds, 0, 0, &tv) > 0) {
    char buf[2048];
    int r = recv(s, buf, sizeof buf, 0);
    if (r > 0) rx.append(buf, r);
    else ok = false;   // 0 = peer close, <0 = error
  }
  return (int)rx.size() - (int)rxp;
}
char WiFiClient::read() {
  if (rxp >= rx.size()) return -1;
  return (char)rx[rxp++];
}
void WiFiClient::stop() {
  if (s != INVALID_SOCKET) { closesocket(s); s = INVALID_SOCKET; }
  ok = false; rx.clear(); rxp = 0;
}

// ---------------- SimFS ----------------
bool SimFS::mkdir(const char *p) {
  std::string f = std::string(root) + p;
  ::mkdir(f.c_str());
  return true;
}
SimFile SimFS::open(const char *p, const char *mode) {
  std::string f = std::string(root) + p;
  if (strchr(p, '/')) {   // dam bao thu muc me
    std::string dir = root; dir += "/";
    for (const char *c = p; *c; c++) { dir += *c; if (*c == '/') ::mkdir(dir.c_str()); }
  }
  SimFile sf; sf.f = fopen(f.c_str(), mode);
  return sf;
}

// ---------------- LGFX ----------------
void LGFX::drawString(const char *s, int x, int y) {
  // font 5x7 don gian de screenshot doc duoc (sim only)
  static const unsigned char F[96][5] = {
    {0,0,0,0,0},{0,0,0x5F,0,0},{0,7,0,7,0},{0x14,0x7F,0x14,0x7F,0x14},{0x24,0x2A,0x7F,0x2A,0x12},
    {0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0,5,3,0,0},{0,0x1C,0x22,0x41,0},
    {0,0x41,0x22,0x1C,0},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},{0,0x50,0x30,0,0},
    {0x08,0x08,0x08,0x08,0x08},{0,0x60,0x60,0,0},{0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E},{0,0x42,0x7F,0x40,0},{0x42,0x61,0x51,0x49,0x46},
    {0x21,0x41,0x45,0x4B,0x31},{0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},
    {0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},{0x36,0x49,0x49,0x49,0x36},
    {0x06,0x49,0x49,0x29,0x1E},{0,0x36,0x36,0,0},{0,0x56,0x36,0,0},{0x08,0x14,0x22,0x41,0},
    {0x14,0x14,0x14,0x14,0x14},{0,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},
    {0x3E,0x41,0x41,0x41,0x22},{0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},
    {0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},{0x7F,0x08,0x08,0x08,0x7F},
    {0,0x41,0x7F,0x41,0},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},
    {0x3E,0x41,0x41,0x41,0x3E},{0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},
    {0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7F,0x01,0x01},
    {0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},
    {0,0x7F,0x41,0x41,0},{0x02,0x04,0x08,0x10,0x20},{0,0x41,0x41,0x7F,0},
    {0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},{0,0x01,0x02,0x04,0},
    {0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},
    {0x0C,0x52,0x52,0x52,0x3E},{0x7F,0x08,0x04,0x04,0x78},{0,0x44,0x7D,0x40,0},
    {0x20,0x40,0x44,0x3D,0},{0x7F,0x10,0x28,0x44,0},{0,0x41,0x7F,0x40,0},
    {0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
    {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},
    {0x48,0x54,0x54,0x54,0x20},{0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},
    {0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},{0x44,0x28,0x10,0x28,0x44},
    {0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0,0x08,0x36,0x41,0},
    {0,0,0x7F,0,0},{0,0x41,0x36,0x08,0},{0x08,0x04,0x08,0x10,0x08},
  };
  int sx = x;
  for (int i = 0; s[i]; i++) {
    unsigned char c = (unsigned char)s[i];
    if (c == ' ') { sx += charW(); continue; }
    if (c < 32 || c > 127) c = '?';
    const unsigned char *g = F[c - 32];
    int scale = (font >= 4) ? 2 : 1;
    for (int col = 0; col < 5; col++) {
      unsigned char bits = g[col];
      for (int row = 0; row < 7; row++) {
        if (bits & (1 << row)) {
          if (scale == 1) drawPixel(sx + col, y + row, fg);
          else fillRect(sx + col * 2, y + row * 2, 2, 2, fg);
        }
      }
    }
    sx += charW();
  }
}
void LGFX::dumpBmp(const char *path) {
  FILE *f = fopen(path, "wb");
  if (!f) return;
  int w = 240, h = 320, row = w * 3;
  unsigned char hdr[54] = {};
  hdr[0] = 'B'; hdr[1] = 'M';
  int size = 54 + row * h;
  memcpy(hdr + 2, &size, 4); hdr[10] = 54;
  hdr[14] = 40; memcpy(hdr + 18, &w, 4); memcpy(hdr + 22, &h, 4);
  hdr[26] = 1; hdr[28] = 24;
  fwrite(hdr, 1, 54, f);
  std::vector<unsigned char> line(row);
  for (int y = h - 1; y >= 0; y--) {
    for (int x = 0; x < w; x++) {
      uint16_t c = fb[y * w + x];
      int r = (c >> 11) << 3, g = ((c >> 5) & 0x3F) << 2, b = (c & 0x1F) << 3;
      line[x * 3 + 0] = (unsigned char)b; line[x * 3 + 1] = (unsigned char)g; line[x * 3 + 2] = (unsigned char)r;
    }
    fwrite(line.data(), 1, row, f);
  }
  fclose(f);
}
