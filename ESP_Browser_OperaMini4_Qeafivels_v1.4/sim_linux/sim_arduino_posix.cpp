#include "sim_arduino_posix.h"
#include <sys/stat.h>
#include <sys/select.h>
#include <fcntl.h>
#include <algorithm>
SimSerial Serial; SimWiFi WiFi; LGFX *LGFX::inst=nullptr; SimFS SD_MMC{"sim_sd"}; SimFS LittleFS{"sim_lfs"};
SimNet SIM_NETS[]={{"VNPT-Home",-52,false},{"TestOpen",-65,true}}; int SIM_NET_COUNT=2; char SIM_CONNECTED[64]=""; char SIM_EXPECT_PASS[64]="abc"; int SIM_KEYS[10]={0};
int sim_digitalRead(int pin){static const int mp[]={18,7,15,45,17,6,8,46,5,16};for(int i=0;i<10;i++)if(mp[i]==pin)return SIM_KEYS[i]?0:1;return 1;}

static bool wait_fd(int fd,int ms){fd_set r;FD_ZERO(&r);FD_SET(fd,&r);timeval tv{ms/1000,(ms%1000)*1000};return select(fd+1,&r,nullptr,nullptr,&tv)>0;}
bool WiFiClient::connect(const char *host,int port,int timeout_ms){(void)timeout_ms;stop();addrinfo hints{},*res=nullptr;hints.ai_socktype=SOCK_STREAM;hints.ai_family=AF_UNSPEC;char ps[16];snprintf(ps,sizeof ps,"%d",port);if(getaddrinfo(host,ps,&hints,&res)!=0||!res)return false;for(addrinfo*p=res;p;p=p->ai_next){fd=socket(p->ai_family,p->ai_socktype,p->ai_protocol);if(fd<0)continue;if(::connect(fd,p->ai_addr,p->ai_addrlen)==0){ok=true;break;}close(fd);fd=-1;}freeaddrinfo(res);if(!ok)return false;if(tls){OPENSSL_init_ssl(0,nullptr);ctx=SSL_CTX_new(TLS_client_method());if(!ctx){stop();return false;}SSL_CTX_set_verify(ctx,SSL_VERIFY_NONE,nullptr);ssl=SSL_new(ctx);if(!ssl){stop();return false;}SSL_set_fd(ssl,fd);SSL_set_tlsext_host_name(ssl,host);if(SSL_connect(ssl)!=1){stop();return false;}}return true;}
void WiFiClient::print(const char*s){if(!ok||!s)return;size_t n=strlen(s),o=0;while(o<n){int r=tls?SSL_write(ssl,s+o,(int)(n-o)):(int)send(fd,s+o,n-o,0);if(r<=0){ok=false;break;}o+=r;}}
int WiFiClient::available(){if(!ok||fd<0)return 0;if(tls&&ssl){int p=SSL_pending(ssl);if(p>0)return p;if(!wait_fd(fd,200))return 0;char c;int r=SSL_peek(ssl,&c,1);if(r>0)return r;ok=false;return 0;}int n=0;if(ioctl(fd,FIONREAD,&n)==0&&n>0)return n;if(!wait_fd(fd,200))return 0;ssize_t r=recv(fd,nullptr,0,MSG_PEEK);(void)r;if(ioctl(fd,FIONREAD,&n)==0&&n>0)return n;char c;ssize_t pr=recv(fd,&c,1,MSG_PEEK|MSG_DONTWAIT);if(pr>0)return (int)pr;if(pr==0)ok=false;return 0;}
char WiFiClient::read(){if(!ok||fd<0)return (char)-1;char c=0;int r=tls?SSL_read(ssl,&c,1):(int)recv(fd,&c,1,0);if(r<=0){ok=false;return (char)-1;}return c;}
void WiFiClient::stop(){if(ssl){SSL_shutdown(ssl);SSL_free(ssl);ssl=nullptr;}if(ctx){SSL_CTX_free(ctx);ctx=nullptr;}if(fd>=0){close(fd);fd=-1;}ok=false;}

static void ensure_parent(const std::string &f){auto pos=f.find_last_of('/');if(pos==std::string::npos)return;std::string cur;for(size_t i=0;i<pos;i++){cur+=f[i];if(f[i]=='/'&&!cur.empty())::mkdir(cur.c_str(),0777);}if(pos)::mkdir(f.substr(0,pos).c_str(),0777);}
bool SimFS::mkdir(const char*p){std::string f=root+p;ensure_parent(f+"/x");::mkdir(f.c_str(),0777);return true;}
SimFile SimFS::open(const char*p,const char*mode){std::string f=root+p;ensure_parent(f);SimFile sf;sf.f=fopen(f.c_str(),mode);return sf;}

// ---------------- LGFX ----------------

void LGFX::drawString(const char *s, int x, int y) {
  // font 5x7 don gian de screenshot doc duoc (sim only)
  static const unsigned char F[96][5] = {
    {0,0,0,0,0},{0,0,0x5F,0,0},{0,7,0,7,0},{0x14,0x7F,0x14,0x7F,0x14},{0x24,0x2A,0x7F,0x2A,0x12},
    {0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x55,0x22,0x50},{0,5,3,0,0},{0,0x1C,0x22,0x41,0},
    {0,0x41,0x22,0x1C,0},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},{0,0x50,0x30,0,0},
    {0x08,0x08,0x08,0x08,0x08},{0,0x60,0x60,0,0},{0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E},{0,0x42,0x7F,0x40,0},{0x42,0x61,0x51,0x49,0x46},
    {0x21,0x41,0x45,0x4B,0x31},{0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},
    {0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},{0x36,0x49,0x49,0x49,0x36},
    {0x06,0x49,0x49,0x29,0x1E},{0,0x36,0x36,0,0},{0,0x56,0x36,0,0},{0x08,0x14,0x22,0x41,0},
    {0x14,0x14,0x14,0x14,0x14},{0,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},
    {0x3E,0x41,0x41,0x41,0x22},{0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},
    {0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A},{0x7F,0x08,0x08,0x08,0x7F},
    {0,0x41,0x7F,0x41,0},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},
    {0x3E,0x41,0x41,0x41,0x3E},{0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},
    {0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7F,0x01,0x01},
    {0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},
    {0,0x7F,0x41,0x41,0},{0x02,0x04,0x08,0x10,0x20},{0,0x41,0x41,0x7F,0},
    {0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40},{0,0x01,0x02,0x04,0},
    {0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},
    {0x0C,0x52,0x52,0x52,0x3E},{0x7F,0x08,0x04,0x04,0x78},{0,0x44,0x7D,0x40,0},
    {0x20,0x40,0x44,0x3D,0},{0x7F,0x10,0x28,0x44,0},{0,0x41,0x7F,0x40,0},
    {0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},
    {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},
    {0x48,0x54,0x54,0x54,0x20},{0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},
    {0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C},{0x44,0x28,0x10,0x28,0x44},
    {0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0,0x08,0x36,0x41,0},
    {0,0,0x7F,0,0},{0,0x41,0x36,0x08,0},{0x08,0x04,0x08,0x10,0x08},
  };
  int sx = x;
  for (int i = 0; s[i]; i++) {
    unsigned char c = (unsigned char)s[i];
    if (c == ' ') { sx += charW(); continue; }
    if (c < 32 || c > 127) c = '?';
    const unsigned char *g = F[c - 32];
    int scale = (font >= 4) ? 2 : 1;
    for (int col = 0; col < 5; col++) {
      unsigned char bits = g[col];
      for (int row = 0; row < 7; row++) {
        if (bits & (1 << row)) {
          if (scale == 1) drawPixel(sx + col, y + row, fg);
          else fillRect(sx + col * 2, y + row * 2, 2, 2, fg);
        }
      }
    }
    sx += charW();
  }
}
void LGFX::dumpBmp(const char *path) {
  FILE *f = fopen(path, "wb");
  if (!f) return;
  int w = 240, h = 320, row = w * 3;
  unsigned char hdr[54] = {};
  hdr[0] = 'B'; hdr[1] = 'M';
  int size = 54 + row * h;
  memcpy(hdr + 2, &size, 4); hdr[10] = 54;
  hdr[14] = 40; memcpy(hdr + 18, &w, 4); memcpy(hdr + 22, &h, 4);
  hdr[26] = 1; hdr[28] = 24;
  fwrite(hdr, 1, 54, f);
  std::vector<unsigned char> line(row);
  for (int y = h - 1; y >= 0; y--) {
    for (int x = 0; x < w; x++) {
      uint16_t c = fb[y * w + x];
      int r = (c >> 11) << 3, g = ((c >> 5) & 0x3F) << 2, b = (c & 0x1F) << 3;
      line[x * 3 + 0] = (unsigned char)b; line[x * 3 + 1] = (unsigned char)g; line[x * 3 + 2] = (unsigned char)r;
    }
    fwrite(line.data(), 1, row, f);
  }
  fclose(f);
}
